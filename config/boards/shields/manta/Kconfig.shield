## config/boards/shields/manta/Kconfig.shield
```kconfig
# Copyright (c) 2021 Jeremy Kitchen
# SPDX-License-Identifier: MIT

config SHIELD_MANTA
       def_bool $(shields_list_contains,manta)
```
